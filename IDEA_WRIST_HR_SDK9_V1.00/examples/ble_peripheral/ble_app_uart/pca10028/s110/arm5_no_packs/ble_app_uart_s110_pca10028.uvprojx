# Keil uVision project ble_app_uart_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxac_s110 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin/fromelf.exe --bin -o ./bin/IDEA_WRIST_HR.bin ./_build/nrf51822_xxac_s110.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0  SPI_FLASH SPI1 OLED DEBUG_LOG IDEA_DEBUG DEBUG_NRF_USER
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\IdeaSource\inc;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\IdeaSource\algorithm_inc;..\..\..\..\..\..\components\drivers_nrf\ble_flash;..\..\..\..\..\..\components\ble\ble_debug_assert_handler;..\..\..\..\..\..\components\ble\ble_error_log;..\..\..\..\..\..\components\drivers_nrf\twi_master\incubated;..\..\..\..\..\..\components\ble\ble_radio_notification;..\..\..\..\..\..\components\IdeaSource\libs;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\ble_services\ble_dis
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
    ../../../../../../components/IdeaSource/src/: idea_battery.c idea_ble_nus.c idea_bluetooth_log.c idea_buzzer.c idea_charging.c idea_communicate_protocol.c idea_crc16.c idea_data_manager.c idea_factory_test.c idea_hal_acc.c idea_input_event_source.c idea_interaction.c idea_led_flash.c idea_level_drive_motor.c idea_lis3dh_driver.c idea_low_power_mode.c idea_menu_display.c idea_nrf_delay.c idea_oled.c idea_private_bond.c idea_spi_flash.c idea_spi_master.c idea_square_root.c idea_stack_dump_repoter.c idea_step_counter.c idea_switch_sleep.c idea_sync_data.c idea_wall_clock_timer.c idea_wdt.c simple_uart.c idea_sw_flash.c idea_event.c idea_ui_menu.c idea_display.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../../components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../../../../../components/ble/ble_error_log/: ble_error_log.c
    ../../../../../../components/ble/ble_radio_notification/: ble_radio_notification.c
    ../../../../../../components/serialization/application/hal/: ser_app_hal_nrf51.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_tps/: ble_tps.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/ble_flash/: ble_flash.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group AlgorithmLib
    ../../../../../../components/IdeaSource/libs/: AlgorithmLibFornrf51.lib
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
